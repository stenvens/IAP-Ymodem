# Keil uVision project HC32F030J8TA.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F030J8TA HDSC
  pack: HDSC.HC32F030.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  AfterMake: "..\Resource\MergeHEX.bat"
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\common;..\source;..\driver\inc;..\bsp;..\iap
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ../common/: system_hc32f030.c
    ./: startup_hc32f030.s
  group source
    ../source/: main.c hal_delay.c version.h
  group driver
    ../driver/src/: ddl.c gpio.c interrupts_hc32f030.c sysctrl.c flash.c
  group bsp
    ../bsp/: bsp_uart.c bsp_sysclk.c bsp_flash.c
  group iap
    ../iap/: common.c menu.c ymodem.c boot_iap.c boot_param.c boot_interface.c boot_interface.h
  group document
    ../update_log/: update_log.txt
software components: CMSIS:CORE 5.4.0
