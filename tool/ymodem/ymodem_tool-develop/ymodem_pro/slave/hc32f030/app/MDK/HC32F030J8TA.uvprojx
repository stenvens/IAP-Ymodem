# Keil uVision project HC32F030J8TA.uvprojx, settings and files
target HC32F030J8TA_Release (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F030J8TA HDSC
  pack: HDSC.HC32F030.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: "..\Resource\MergeHEX.bat"
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\common;..\source;..\driver\inc;..\bsp;..\funclib
  library: MicroLIB
  memory RVCT4: ROM 0x1c00 size 0xe400
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ../common/: system_hc32f030.c
    ./: startup_hc32f030.s
  group source
    ../source/: main.c delay.c system_config.h
  group driver
    ../driver/src/: ddl.c gpio.c interrupts_hc32f030.c sysctrl.c flash.c adc.c
  group bsp
    ../bsp/: bsp_uart.c bsp_sysclk.c bsp_flash.c
  group funclib
    ../funclib/: boot_interface.h boot_iap.c uart_config.c
software components: CMSIS:CORE 5.4.0
