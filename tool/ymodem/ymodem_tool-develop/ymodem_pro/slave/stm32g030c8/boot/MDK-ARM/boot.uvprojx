# Keil uVision project boot.uvprojx, settings and files
target boot (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: "..\Resource\MergeHEX.bat"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,DATA_CACHE_ENABLE=1,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\bsp;..\funclib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c hal_delay.c
    ../Core/Inc/: main.h version.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_ll_pwr.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_dma.c stm32g0xx_ll_utils.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group bsp
    ../bsp/: bsp_uart.c bsp_sysclk.c bsp_flash.c
  group iap
    ../funclib/: common.c menu.c ymodem.c boot_iap.c boot_param.c boot_interface.c boot_interface.h
  group document
    ../update_log/: update_log.txt
software components: CMSIS:CORE 5.4.0
